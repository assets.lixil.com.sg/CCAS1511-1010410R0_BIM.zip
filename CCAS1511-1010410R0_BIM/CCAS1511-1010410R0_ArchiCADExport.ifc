Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2026-03-28T17:44:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 28 17:44:03 2026 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\eb6a840a-ce91-41c7-8a7e-f14afa6849cf\54b89af4-2e5c-4261-97f8-d602813fdcf2\ifc * Database version: 5507 * Database creation date: Sat Mar 28 17:44:00 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 28 17:44:01 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 28 17:44:01 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_348355 | SINK
Port_348355 | SOURCE

# IfcFlowTerminal: CCAS1511-1000410R0:CCAS1511-1000410R0, CCAS1511-1000410R0:CCAS1511-1000410R0:348355
In: Level 1
Type - Material: American Standard - Vitreous China - White, American Standard - Brass
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: CCAS1511-1000410R0
Material: American Standard - Brass, American Standard - Vitreous China - White
Pset_DistributionFlowElementCommon - Reference: CCAS1511-1000410R0; sets with these values: 2
